# IAR project multi_encoder.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC822M101 NXP LPC822M101
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0PLUS; NO_BOARD_LIB
  ICCARM.CCIncludePath2: ..\chip_82x\inc; ..\user
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: multi_encoder.srec
  ILINK.IlinkOutputFile: multi_encoder.out
  ILINK.IlinkIcfFile: multi_encoder.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Chip
    ../chip_82x/src/: acmp_8xx.c adc_8xx.c chip_8xx.c clock_8xx.c crc_8xx.c dma_8xx.c eeprom.c gpio_8xx.c i2c_common_8xx.c i2cm_8xx.c i2cs_8xx.c iap.c iocon_8xx.c irc_8xx.c pinint_8xx.c pmu_8xx.c ring_buffer.c rtc_ut.c sct_8xx.c sct_pwm_8xx.c spi_8xx.c spim_8xx.c spis_8xx.c stopwatch_8xx.c swm_8xx.c syscon_8xx.c sysinit_8xx.c uart_8xx.c wkt_8xx.c wwdt_8xx.c
  group Startup
    ../chip_82x/startup/: iar_startup_lpc82x.s sysinit.c
  group User
    ../user/: calc_value.c ecd_flash.c led.c main.c mlx90316.c spi_slaver.c
